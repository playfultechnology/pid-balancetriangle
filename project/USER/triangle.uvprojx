# Keil uVision project triangle.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1
  c define: STM32F10X_LD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\BALANCE\CONTROL;..\HARDWARE\ENCODER;..\BALANCE\CONTROL;..\BALANCE\DataScope_DP;..\BALANCE\show;..\BALANCE\controls;..\HARDWARE\EXTI;..\HARDWARE\pid;..\STM32F10x_FWLib\inc;..\USER;..\HARDWARE\DMP;..\HARDWARE\I2C;..\HARDWARE\mpu6050;..\BALANCE\filter;..\CORE;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/I2C/: I2C.c
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group BALANCE
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/show/: show.c
    ../BALANCE/filter/: filter.c
  group LIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CORE
    ../CORE/: core_cm3.c
